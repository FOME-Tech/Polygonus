File: ign4.kicad_sch (KiCad schematic)
At the start: 16 parts, among them U42 MIC4427, U43 MIC4427

Commit message: sa
Parts:
- renumbered R87 to R1501, R87 to R1502, R87 to R1503, R87 to R1504
